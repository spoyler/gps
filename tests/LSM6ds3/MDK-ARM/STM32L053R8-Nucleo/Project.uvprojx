# Keil uVision project Project.uvprojx, settings and files
target STM32L051_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L053R8_NUCLEO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\Src\lsm6ds0;..\..\Src\lsm6ds3;..\..\Src\X_NUCLEO_IKS01A1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Example/User
    ../../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c clock_l0.c debug.c
  group lsm6ds0
    ../../Src/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
  group lsm6ds3
    ../../Src/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group X_NUCLEO_IKS01A1
    ../../Src/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c
software components: CMSIS:CORE 4.3.0
